# Keil uVision project Project.uvprojx, settings and files
target ZQ_STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL
  c include: ..\src;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\Utilities\Third_Party\lwip_v1.3.2\src\netif;..\inc;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\arch;..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\..\Utilities\Third_Party\lwip_v1.3.2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c netconf.c stm32f4x7_eth_bsp.c stm32f4xx_it.c UDP_SERVER.C delay.c KEY.C LCD_12864.C LED.C NRF24L01.c SCI.c spi.c
  group LwIP
    ../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
